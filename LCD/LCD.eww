<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LCD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>LCD</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>LCD</project>
        <configuration>SRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



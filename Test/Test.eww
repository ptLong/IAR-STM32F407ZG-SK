<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Test.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Test</project>
        <configuration>Flash Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



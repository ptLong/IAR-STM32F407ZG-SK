<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\arm_class_marks_example\arm_class_marks_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_convolution_example\arm_convolution_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_dotproduct_example\arm_dotproduct_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_fft_bin_example\arm_fft_bin_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_fir_example\arm_fir_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_graphic_equalizer_example\arm_graphic_equalizer_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_linear_interp_example\arm_linear_interp_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_matrix_example\arm_matrix_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_signal_converge_example\arm_signal_converge_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_sin_cos_example\arm_sin_cos_example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\arm_variance_example\arm_variance_example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>arm_class_marks_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_convolution_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_dotproduct_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_fft_bin_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_fir_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_graphic_equalizer_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_signal_converge_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_sin_cos_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_variance_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_linear_interp_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
      <member>
        <project>arm_matrix_example</project>
        <configuration>Cortex_M4</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Buzzer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Buzzer</project>
        <configuration>Flash Debug</configuration>
      </member>
      <member>
        <project>Buzzer</project>
        <configuration>SRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


